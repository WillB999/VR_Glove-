# Keil uVision project SmartGloves.uvproj, settings and files
target SmartGloves (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ISD9160 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x233FF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: SmartGloves_APROM +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: DEBUG_ENABLE_SEMIHOS,__ISD9100__
  c include: .;..\;C:\Nuvoton ISD9100 SDS\V5.02.001\Library\CMSIS\Include;C:\Nuvoton ISD9100 SDS\V5.02.001\Library\Device\Nuvoton\ISD9100\Include;C:\Nuvoton ISD9100 SDS\V5.02.001\Library\StdDriver\inc;C:\Nuvoton ISD9100 SDS\V5.02.001\Library\Storage\inc;C:\Nuvoton ISD9100 SDS\V5.02.001\Library\Framework\inc;C:\Nuvoton ISD9100 SDS\V5.02.001\Library\Audio\inc
  memory RVCT4: ROM 0x0 size 0x24400
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='startup_ISD9100.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    C:/Nuvoton ISD9100 SDS/V5.02.001/Library/Device/Nuvoton/ISD9100/Source/: system_ISD9100.c
    C:/Nuvoton ISD9100 SDS/V5.02.001/Library/Device/Nuvoton/ISD9100/Source/ARM/: startup_ISD9100.s
  group User
    ../: main.c InterruptHandler.c WaveRecord.c OverLapRam.c VR.c
  group Library
    C:/Nuvoton ISD9100 SDS/V5.02.001/Library/StdDriver/src/: adc.c biq.c clk.c dpwm.c fmc.c gpio.c pdma.c retarget.c spi.c sys.c uart.c timer.c
    C:/Nuvoton ISD9100 SDS/V5.02.001/SampleCode/VR Projects/Cyberon_NuOne_630.1/6.3.0_Release/: libCSpotterSDK_16k24d_ISD9xxC_arm-cm0.lib
  group Storage
    C:/Nuvoton ISD9100 SDS/V5.02.001/Library/Storage/src/: SPIFlash.c
  group Framework
    C:/Nuvoton ISD9100 SDS/V5.02.001/Library/Framework/src/: AudioRom.c MicSpk.c PdmaCtrl.c
  group NuOne
    ../NuOne/: AppCallback.c PlaySpiNuOne.c
    C:/Nuvoton ISD9100 SDS/V5.02.001/Library/Audio/arm/: NuOneEx_Keil.lib
